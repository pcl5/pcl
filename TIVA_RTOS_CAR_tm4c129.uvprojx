# Keil uVision project TIVA_RTOS_CAR_tm4c129.uvprojx, settings and files
target TIVA_RTOS_CAR_tm4c129 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C1290NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TIVA_RTOS_CAR_tm4c129 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: rvmdk PART_TM4C1290NCPDT
  c include: .\User;.\Lib;.\Lib\inc;.\FreeRTOS\include;.\FreeRTOS\port\RVDS\ARM_CM4F;\User\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group User
    ./User/: main.c freertos.c
  group Startup
    ./Startup/: startup_rvmdk.S
  group Lib/driverlib
    ./Lib/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group Lib/utils
    ./Lib/utils/: uartstdio.c
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ./FreeRTOS/port/MemMang/: heap_4.c
    ./FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group Lib/sensorlib
    ./Lib/sensorlib/: i2cm_drv.c
  group User/BSP
    ./User/BSP/: bsp_gpio.c bsp_LED.c bsp_key.c bsp_uart.c bsp_pwm.c bsp_motor.c
